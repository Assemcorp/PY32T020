# Keil uVision project Py32t020xx_Touch.uvprojx, settings and files
target Py32t020xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Py32t020xx_TouchKey_StartKit +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32T020x6,USE_FULL_LL_DRIVER,LIB_TYPE = 1,
  c include: ..\Inc;..\..\Drivers\BSP\PY32T020xx_Start_Kit;..\..\Drivers\CMSIS\Include;..\..\Drivers\PY32T020_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\PY32T020\Include;..\..\lib_c;..\..\Touch_Lib;..\..\app_drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Common
    ./: startup_py32t020xx.s
    ../Src/: system_py32t020.c
  group Application/User
    ../Src/: main.c
  group app_task
    ../../app_drivers/inc/: app_config.h
    ../../app_drivers/src/: drivers.c smg_task.c adc_task.c uart_task.c argb_task.c
  group app_drivers
    ../../app_drivers/src/: gpio.c uart_drivers.c tim1_drivers.c tim14_drivers.c smg_drivers.c beep_drivers.c adc_drivers.c tm1624.c tm1640.c ir_received.c spi-led_drivers.c user-otp_drivers.c py32t020_flash.c
  group Drivers/PY32T020_LL_Driver
    ../../Drivers/PY32T020_HAL_Driver/Src/: py32t020_ll_adc.c py32t020_ll_comp.c py32t020_ll_crc.c py32t020_ll_exti.c py32t020_ll_gpio.c py32t020_ll_i2c.c py32t020_ll_pwr.c py32t020_ll_rcc.c py32t020_ll_spi.c py32t020_ll_tim.c py32t020_ll_uart.c py32t020_ll_utils.c
  group TK_user
    ../Inc/: tk_cfg_user.h tk_cfg.h
    ../Src/: tk_user.c
  group TK_Lib
    ../../Touch_Lib/: Py32t020xx_sample_V1.2.13.lib
target lib-0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.2
  cpu: as above
  output: Py32t020xx_only_touchkey_V1.2.13. +hex (library)
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32T020x6,USE_LL_DRIVER,LIB_TYPE = 0,
  c include: ..\Inc;..\..\Drivers\BSP\PY32T020xx_Start_Kit;..\..\Drivers\CMSIS\Include;..\..\Drivers\PY32T020_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\PY32T020\Include;..\..\lib_c;..\..\Touch_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target lib-1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.2
  cpu: as above
  output: Py32t020xx_sample_V1.2.13. +hex (library)
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32T020x6,USE_LL_DRIVER,LIB_TYPE = 1,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
target lib-2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32T020x6 Puya
  pack: Puya.PY32T0xx_DFP.1.0.2
  cpu: as above
  output: Py32t020xx_waterproof_V1.2.13. +hex (library)
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32T020x6,USE_LL_DRIVER,LIB_TYPE = 2,
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
software components: CMSIS:CORE 5.2.0
